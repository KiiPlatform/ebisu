# Keil uVision project WM_SDK.uvproj, settings and files
target WM_SDK (ARM-ADS)
  device: ARM966E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM966E-S)
  output: WM_SDK +hex
  AfterMake: fromelf .\objs\WM_SDK.axf --bin -o ..\..\..\Bin\WM_SDK.bin
  AfterMake: createimg.bat
  c flags: Optim=4 wLevel=2
  c misc: --c99 --gnu
  c include: ..\..\..\Src\Drivers;..\..\..\Src\Drivers\dma;..\..\..\Src\Drivers\efuse;..\..\..\Src\Drivers\flash;..\..\..\Src\Drivers\gpio;..\..\..\Src\Drivers\hspi;..\..\..\Src\Drivers\litepoint;..\..\..\Src\Drivers\spi;..\..\..\Src\Drivers\timer;..\..\..\Src\Drivers\uart;..\..\..\Src\Drivers\watchdog;..\..\..\Src\Misc;..\..\..\Src\Network\lwip1.4.1;..\..\..\Src\Network\lwip1.4.1\include;..\..\..\Src\Network\lwip1.4.1\include\arch;..\..\..\Src\Network\lwip1.4.1\include\ipv4;..\..\..\Src\Network\lwip1.4.1\include\ipv4\lwip;..\..\..\Src\Network\lwip1.4.1\include\lwip;..\..\..\Src\Network\lwip1.4.1\include\netif;..\..\..\Src\OS\uCOS-II\ports;..\..\..\Src\OS\uCOS-II\source;..\..\..\Src\Wlan\Driver;..\..\..\Src\Wlan\Supplicant;..\..\..\Include;..\..\..\Src\Inc;..\..\..\Src\Sys;..\..\..\Src\Network\api;..\..\..\App\wm_atcmd;..\..\..\App\demo;..\..\..\Src\Common\Params;..\..\..\Src\Drivers\litepoint;..\..\..\Src\MQTT
  memory RVCT6: RAM 0x0 size 0x60000
  scatter file: ..\tl6_sdk.sct
  link misc: --entry=start.o(RESET)
  group App/Demo
    ../../../App/demo/: wm_connect_net_demo.c wm_crypt_demo.c wm_demo_console_task.c wm_flash_demo.c wm_gpio_demo.c wm_http_demo.c wm_http_fwup.c wm_master_spi_demo.c wm_mcast_demo.c wm_raw_socket_client_demo.c wm_raw_socket_server_demo.c wm_slave_spi_demo.c wm_socket_client_demo.c wm_socket_fwup.c wm_socket_fwup_demo.c wm_socket_server_demo.c wm_socket_server_sel_demo.c wm_softap_demo.c wm_uart_demo.c wm_wps_demo.c
  group App/DhcpServer
    ../../../App/dhcpserver/: dhcp_server.c
  group App/DnsServer
    ../../../App/dnsserver/: dns_server.c
  group App/httpClient
    ../../../App/httpclient/: HTTPClient.c HTTPClientAuth.c HTTPClientString.c HTTPClientWrapper.c
  group App/wm_atcmd
    ../../../App/wm_atcmd/: wm_cmdp.c wm_cmdp_at.c wm_cmdp_hostif.c wm_cmdp_ri.c wm_hspi_task.c wm_uart_task.c wm_uart_timer.c
  group App/oneshot
    ../../../App/oneshotconfig/: wm_wifi_oneshot.c
  group App/main
    ../../../App/: main.c wm_main.c
  group Include
    ../../../Include/: list.h wm_crypto.h wm_dma.h wm_flash.h wm_fls_gd25qxx.h wm_gpio.h wm_hostspi.h wm_hspi.h wm_http_client.h wm_http_fwup.h wm_ieee80211.h wm_include.h wm_os.h wm_regs.h wm_socket.h wm_sockets.h wm_sys.h wm_timer.h wm_type_def.h wm_uart.h wm_wifi.h wm_wifi_oneshot.h
  group src/network/api
    ../../../Src/Network/api/: tls_sockets.c tls_netconn.c
  group src/os/os_ports
    ../../../Src/OS/os_ports/: clock.c
  group Src/ucosII/source
    ../../../Src/OS/uCOS-II/source/: ucos_ii.c
  group Src/ucosII/ports
    ../../../Src/OS/uCOS-II/ports/: os_cpu_c.c os_cpu_a.s
  group Src/Drivers/spi
    ../../../Src/Drivers/spi/: wm_hostspi.c
  group Src/Drivers/timer
    ../../../Src/Drivers/timer/: wm_timer.c
  group Src/Drivers/uart
    ../../../Src/Drivers/uart/: wm_uart.c
  group Src/Drivers/dma
    ../../../Src/Drivers/dma/: wm_dma.c
  group Src/Drivers/efuse
    ../../../Src/Drivers/efuse/: wm_efuse.c
  group Src/Drivers/flash
    ../../../Src/Drivers/flash/: wm_fls.c wm_fls_gd25qxx.c
  group Src/Drivers/gpio
    ../../../Src/Drivers/gpio/: wm_gpio.c
  group Src/Drivers/hspi
    ../../../Src/Drivers/hspi/: wm_hspi.c
  group src/Drivers/cpu
    ../../../Src/Drivers/cpu/: wm_cpu.c
  group src/Drivers/irq
    ../../../Src/Drivers/irq/: wm_irq.c
  group Src/Network/lwip1.4.1/api
    ../../../Src/Network/lwip1.4.1/api/: tcpip.c api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c
  group Src/Network/lwip1.4.1/core
    ../../../Src/Network/lwip1.4.1/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group Src/Network/lwip1.4.1/core/ipv4
    ../../../Src/Network/lwip1.4.1/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group Src/Network/lwip1.4.1/netif
    ../../../Src/Network/lwip1.4.1/netif/: etharp.c ethernetif.c
  group Src/Network/lwip1.4.1
    ../../../Src/Network/lwip1.4.1/: ethernet.c sys_arch.c
  group Src/Inc
    ../../../Src/Inc/: bitops.h tls_common.h tls_efuse.h tls_ieee80211.h tls_sys.h tls_wireless.h utils.h
  group Src/Boot
    ../../../Src/Boot/: retarget.c mpu.s start.s
  group Src/Sys
    ../../../Src/Sys/: tls_sys.c
  group src/common/mem
    ../../../Src/Common/mem/: wm_mem.c
  group src/common/utils
    ../../../Src/Common/utils/: utils.c
  group src/common/fwup
    ../../../Src/Common/fwup/: wm_fwup.c
  group Wifi/Lib
    ../../../Lib/KEIL/: wifi.lib
  group src/kii
    ../../../Src/Kii/: kii.c kii_demo.c kii_device.c kii_hal.c kii_object.c kii_user.c kii_push.c kii_mqtt.c
  group src/MQTT
    ../../../Src/MQTT/: MQTTClient.c MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c WinnerMicro.c
